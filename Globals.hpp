#pragma once
#include <BLEDevice.h>
#include <BLEScan.h>
#include <SPI.h>
#include <Wire.h>
#include <Adafruit_GFX.h>
#include <Adafruit_SSD1306.h>
#include <Arduino.h>
#include <BLEDevice.h>
#include <BLEUtils.h>
#include <BLEAdvertising.h>
#include "Deauther.hpp"
#include <esp_bt.h>
#include <esp_bt_main.h>
#include <esp_bt_device.h>
#include <esp_gap_ble_api.h>
#include <esp_gatts_api.h>
#include <BLEServer.h>
#include "esp_mac.h"
#include <Preferences.h>

extern bool bleInitialized;
extern bool bleScanning;
extern bool bleSnifferRunning;
void stopBLEScan();
void stopBLESniffer();
static bool wifiForcedOff = false;

void ensureWiFiOffForBLE() {
  if (WiFi.getMode() != WIFI_OFF) {
    WiFi.disconnect(true);
    WiFi.mode(WIFI_OFF);
    esp_wifi_deinit();
    wifiForcedOff = true;
    delay(100);
    Serial.printf("[RADIO] WiFi off, Heap: %u\n", ESP.getFreeHeap());
  }
}

void ensureBLEOffForWiFi() {
  if (bleInitialized) {
    BLEDevice::deinit(false);
    bleInitialized = false;
    delay(100);
  }
  WiFi.disconnect(true);
  WiFi.mode(WIFI_OFF);
  delay(100);
}

#define DECODE_PIONEER
#define SEND_PIONEER
#include <IRremote.hpp>

#define SCREEN_WIDTH 128
#define SCREEN_HEIGHT 64
Adafruit_SSD1306 display(SCREEN_WIDTH, SCREEN_HEIGHT, &Wire);

void clampScroll(int itemCount);

const int SubmitbuttonPin = 13;
const int LeftbuttonPin   = 12; 
const int RightbuttonPin  = 14;
const int UpbuttonPin     = 27;
const int DownbuttonPin   = 26;
const int rootPin = 0;
#define BUZZER_PIN 18

const int MAX_WLAN_RESULTS = 10;
String wlanScanMenu[MAX_WLAN_RESULTS];
bool wlanOpen[MAX_WLAN_RESULTS];
int wlanScanCount = 0;
String wlanLastError = "";

String connectSSID = "";
String connectPassword = "";
int wlanCharIndex = 1;
const char wlanCharset[] = " abcdefghijklmnopqrstuvwxyzABCDEFGHIJKLMNOPQRSTUVWXYZ0123456789!@#$%^&*()-_=+.,:;?/";
const int wlanCharsetLen = sizeof(wlanCharset) - 1;

unsigned long wlanConnectStart = 0;
const unsigned long WLAN_CONNECT_TIMEOUT = 15000;

Preferences wifiPrefs;

static const unsigned char PROGMEM image_BLE_beacon_bits[] = {0x44,0x92,0xaa,0x92,0x54,0x10,0x10,0x7c};
static const unsigned char PROGMEM image_Pin_star_bits[]   = {0x92,0x54,0x38,0xfe,0x38,0x54,0x92};

void drawWifiStatusIcon() {
  if (WiFi.status() == WL_CONNECTED) {
    display.drawBitmap(110, 0, image_BLE_beacon_bits, 7, 8, SSD1306_WHITE);
  } else {
    display.drawBitmap(110, 0, image_Pin_star_bits, 7, 7, SSD1306_WHITE);
  }
}

void refreshDisplay() {
  drawWifiStatusIcon();
  display.display();
}

bool bleScanNeedsRestart = false;
bool bleScanDirty = false;
void bleScanTick();

#define MAX_BLE_RESULTS 12
#define MAX_BLE_DETAIL_LINES 10

struct BLEDeviceInfo {
  uint8_t address[6];
  uint8_t addrType;
  bool updated;
  String name;
  int rssi;
  
  uint16_t appearance = 0;
  uint8_t serviceCount = 0;
  String serviceUuids[4];
  String manufacturerData;
  String deviceType = "Unbekannt";
  int lineCount = 0;
  String lines[12];
};

bool lastUpState = HIGH;
bool lastDownState = HIGH;
bool lastSubmitState = HIGH;
bool lastLeftState = HIGH;
bool lastRightState = HIGH;
const int longPressTime = 10;
unsigned long buttonPressedTime = 0;
bool isPressing = false;
bool longPressExecuted = false;

int Menu = true;
int Game = false;
int Game2 = false;
int Game4 = false;
int Game5 = false;
int Spam = false;
int starter = false;
int startr = false;

Preferences preferences;
int currentMode = 0;
int identification = 0;
int settings_Display = 0;
int brightnessValue = 1;
int utcValue = 1;
int buzzerVol = 100;

BLEAdvertising *pAdvertising;
int deviceType = 4;
int delaySeconds = 2;
int advType = 2;

int attack_state = 1;
int device_choice = 0;
int device_index = 0;

int deauthTargetIndex = 0;
unsigned long lastDeauthMillis = 0;
const int deauthInterval = 30;
BLEUUID device_uuid("00003082-0000-1000-9000-00805f9b34fb");
int spam_count = 1;
uint32_t delayMilliseconds = 200;
const uint8_t DEVICES[][31] = {
  // Airpods
  {0x1e, 0xff, 0x4c, 0x00, 0x07, 0x19, 0x07, 0x02, 0x20, 0x75, 0xaa, 0x30, 0x01, 0x00, 0x00, 0x45, 0x12, 0x12, 0x12, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
  // Airpods Pro
  {0x1e, 0xff, 0x4c, 0x00, 0x07, 0x19, 0x07, 0x0e, 0x20, 0x75, 0xaa, 0x30, 0x01, 0x00, 0x00, 0x45, 0x12, 0x12, 0x12, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
  // Airpods Max
  {0x1e, 0xff, 0x4c, 0x00, 0x07, 0x19, 0x07, 0x0a, 0x20, 0x75, 0xaa, 0x30, 0x01, 0x00, 0x00, 0x45, 0x12, 0x12, 0x12, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
  // Airpods Gen 2
  {0x1e, 0xff, 0x4c, 0x00, 0x07, 0x19, 0x07, 0x0f, 0x20, 0x75, 0xaa, 0x30, 0x01, 0x00, 0x00, 0x45, 0x12, 0x12, 0x12, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
  // Airpods Gen 3
  {0x1e, 0xff, 0x4c, 0x00, 0x07, 0x19, 0x07, 0x13, 0x20, 0x75, 0xaa, 0x30, 0x01, 0x00, 0x00, 0x45, 0x12, 0x12, 0x12, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
  // Airpods Pro Gen 2
  {0x1e, 0xff, 0x4c, 0x00, 0x07, 0x19, 0x07, 0x14, 0x20, 0x75, 0xaa, 0x30, 0x01, 0x00, 0x00, 0x45, 0x12, 0x12, 0x12, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
  // Power Beats
  {0x1e, 0xff, 0x4c, 0x00, 0x07, 0x19, 0x07, 0x03, 0x20, 0x75, 0xaa, 0x30, 0x01, 0x00, 0x00, 0x45, 0x12, 0x12, 0x12, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
  // Power Beats Pro
  {0x1e, 0xff, 0x4c, 0x00, 0x07, 0x19, 0x07, 0x0b, 0x20, 0x75, 0xaa, 0x30, 0x01, 0x00, 0x00, 0x45, 0x12, 0x12, 0x12, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
  // Beats Solo Pro
  {0x1e, 0xff, 0x4c, 0x00, 0x07, 0x19, 0x07, 0x0c, 0x20, 0x75, 0xaa, 0x30, 0x01, 0x00, 0x00, 0x45, 0x12, 0x12, 0x12, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
  // Beats Studio Buds
  {0x1e, 0xff, 0x4c, 0x00, 0x07, 0x19, 0x07, 0x11, 0x20, 0x75, 0xaa, 0x30, 0x01, 0x00, 0x00, 0x45, 0x12, 0x12, 0x12, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
  // Beats Flex
  {0x1e, 0xff, 0x4c, 0x00, 0x07, 0x19, 0x07, 0x10, 0x20, 0x75, 0xaa, 0x30, 0x01, 0x00, 0x00, 0x45, 0x12, 0x12, 0x12, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
  // Beats X
  {0x1e, 0xff, 0x4c, 0x00, 0x07, 0x19, 0x07, 0x05, 0x20, 0x75, 0xaa, 0x30, 0x01, 0x00, 0x00, 0x45, 0x12, 0x12, 0x12, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
  // Beats Solo 3
  {0x1e, 0xff, 0x4c, 0x00, 0x07, 0x19, 0x07, 0x06, 0x20, 0x75, 0xaa, 0x30, 0x01, 0x00, 0x00, 0x45, 0x12, 0x12, 0x12, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
  // Beats Studio 3
  {0x1e, 0xff, 0x4c, 0x00, 0x07, 0x19, 0x07, 0x09, 0x20, 0x75, 0xaa, 0x30, 0x01, 0x00, 0x00, 0x45, 0x12, 0x12, 0x12, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
  // Beats Studio Pro
  {0x1e, 0xff, 0x4c, 0x00, 0x07, 0x19, 0x07, 0x17, 0x20, 0x75, 0xaa, 0x30, 0x01, 0x00, 0x00, 0x45, 0x12, 0x12, 0x12, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
  // Betas Fit Pro
  {0x1e, 0xff, 0x4c, 0x00, 0x07, 0x19, 0x07, 0x12, 0x20, 0x75, 0xaa, 0x30, 0x01, 0x00, 0x00, 0x45, 0x12, 0x12, 0x12, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
  // Beats Studio Buds Plus
  {0x1e, 0xff, 0x4c, 0x00, 0x07, 0x19, 0x07, 0x16, 0x20, 0x75, 0xaa, 0x30, 0x01, 0x00, 0x00, 0x45, 0x12, 0x12, 0x12, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
};

const uint8_t SHORT_DEVICES[][23] = {
  // AppleTV Setup
  {0x16, 0xff, 0x4c, 0x00, 0x04, 0x04, 0x2a, 0x00, 0x00, 0x00, 0x0f, 0x05, 0xc1, 0x01, 0x60, 0x4c, 0x95, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00},
  // AppleTV Pair
  {0x16, 0xff, 0x4c, 0x00, 0x04, 0x04, 0x2a, 0x00, 0x00, 0x00, 0x0f, 0x05, 0xc1, 0x06, 0x60, 0x4c, 0x95, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00},
  // AppleTV New User
  {0x16, 0xff, 0x4c, 0x00, 0x04, 0x04, 0x2a, 0x00, 0x00, 0x00, 0x0f, 0x05, 0xc1, 0x20, 0x60, 0x4c, 0x95, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00},
  // AppleTV AppleID Setup
  {0x16, 0xff, 0x4c, 0x00, 0x04, 0x04, 0x2a, 0x00, 0x00, 0x00, 0x0f, 0x05, 0xc1, 0x2b, 0x60, 0x4c, 0x95, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00},
  // AppleTV Wireless Audio Sync
  {0x16, 0xff, 0x4c, 0x00, 0x04, 0x04, 0x2a, 0x00, 0x00, 0x00, 0x0f, 0x05, 0xc1, 0xc0, 0x60, 0x4c, 0x95, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00},
  // AppleTV Homekit Setup
  {0x16, 0xff, 0x4c, 0x00, 0x04, 0x04, 0x2a, 0x00, 0x00, 0x00, 0x0f, 0x05, 0xc1, 0x0d, 0x60, 0x4c, 0x95, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00},
  // AppleTV Keyboard Setup
  {0x16, 0xff, 0x4c, 0x00, 0x04, 0x04, 0x2a, 0x00, 0x00, 0x00, 0x0f, 0x05, 0xc1, 0x13, 0x60, 0x4c, 0x95, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00},
  // AppleTV Connecting to Network
  {0x16, 0xff, 0x4c, 0x00, 0x04, 0x04, 0x2a, 0x00, 0x00, 0x00, 0x0f, 0x05, 0xc1, 0x27, 0x60, 0x4c, 0x95, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00},
  // Homepod Setup
  {0x16, 0xff, 0x4c, 0x00, 0x04, 0x04, 0x2a, 0x00, 0x00, 0x00, 0x0f, 0x05, 0xc1, 0x0b, 0x60, 0x4c, 0x95, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00},
  // Setup New Phone
  {0x16, 0xff, 0x4c, 0x00, 0x04, 0x04, 0x2a, 0x00, 0x00, 0x00, 0x0f, 0x05, 0xc1, 0x09, 0x60, 0x4c, 0x95, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00},
  // Transfer Number
  {0x16, 0xff, 0x4c, 0x00, 0x04, 0x04, 0x2a, 0x00, 0x00, 0x00, 0x0f, 0x05, 0xc1, 0x02, 0x60, 0x4c, 0x95, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00},
  // TV Color Balance
  {0x16, 0xff, 0x4c, 0x00, 0x04, 0x04, 0x2a, 0x00, 0x00, 0x00, 0x0f, 0x05, 0xc1, 0x1e, 0x60, 0x4c, 0x95, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00},
  // Vision Pro
  {0x16, 0xff, 0x4c, 0x00, 0x04, 0x04, 0x2a, 0x00, 0x00, 0x00, 0x0f, 0x05, 0xc1, 0x24, 0x60, 0x4c, 0x95, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00},
};

static const unsigned char PROGMEM image_paint_10_bits[] = {0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x80};
static const unsigned char PROGMEM image_paint_16_bits[] = {0xf8,0x38,0x08,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0x38,0xf8};
static const unsigned char PROGMEM image_paint_17_bits[] = {0xf0,0x00,0x00,0x00,0x0e,0x00,0x00,0x00,0x04,0x00,0x07,0x80,0x07,0x80,0x04,0x00,0x00,0x00,0x0e,0x00,0x00,0x00,0xf0,0x00};
static const unsigned char PROGMEM image_paint_19_bits[] = {0x00,0x00,0x00,0x70,0x0f,0xff,0xff,0xfc,0x7f,0xff,0xff,0x80,0xff,0xff,0xff,0xe0};
static const unsigned char PROGMEM image_paint_19_copy_1_bits[] = {0xff,0xff,0xff,0xe0,0x7f,0xff,0xff,0x80,0x0f,0xff,0xff,0xfc,0x00,0x00,0x00,0x70};
static const unsigned char PROGMEM image_paint_2_2_bits[] = {0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0x3f,0xff,0xff,0xff,0xff,0xff,0xff,0xfc,0x07,0xff,0xff,0xff,0xff,0xff,0xff,0xe0,0x00,0xff,0xff,0xff,0xff,0xff,0xff,0x80,0x00,0x3f,0xff,0xff,0xff,0xff,0xfc,0x00,0x00,0x07,0xff,
0xff,0xff,0xff,0xf0,0x00,0x00,0x00,0xff,0xff,0xff,0xff,0x80,0x00,0x00,0x00,0x3f,0xff,0xff,0xfc,0x00,0x00,0x00,0x00,0x07,0xff,0xff,0xf0,0x00,0x00,0x00,0x00,0x00,0xff,0xff,0x80,0x00,0x00,0x00,0x00,0x00,0x3f,0xfe,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xf0,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x80,0x00,0x00,0x00};
static const unsigned char PROGMEM image_paint_2_copy_1_bits[] = {0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0f,0xe0,0x00,0x00,0x00,0x00,0x00,0x00,0x7f,0xfc,0x00,0x00,0x00,0x00,0x00,0x01,0xff,0xff,0x00,0x00,0x00,0x00,0x00,0x0f,0xff,0xff,0xe0,0x00,0x00,0x00,0x00,
0x3f,0xff,0xff,0xfc,0x00,0x00,0x00,0x01,0xff,0xff,0xff,0xff,0x00,0x00,0x00,0x0f,0xff,0xff,0xff,0xff,0xe0,0x00,0x00,0x3f,0xff,0xff,0xff,0xff,0xfc,0x00,0x01,0xff,0xff,0xff,0xff,0xff,0xff,0x00,0x07,0xff,0xff,0xff,0xff,0xff,0xff,0xe0,0x3f,0xff,0xff,0xff,0xff,0xff,0xff,0xfc,0xff,
0xff,0xff,0xff,0xff,0xff,0xff,0xff};
static const unsigned char PROGMEM image_paint_21_bits[] = {0xf8,0xe0,0xf0,0xfe,0xfe,0xf0};
static const unsigned char PROGMEM image_paint_24_bits[] = {0xc0,0x00,0x00,0x00,0x00,0x00,0x00,0xc0};
static const unsigned char PROGMEM image_paint_25_1_bits[] = {0x00,0x38,0x03,0xf8,0x1f,0xe0,0x7e,0x00,0xf0,0x00};
static const unsigned char PROGMEM image_paint_25_2_bits[] = {0x00,0x00,0x00,0x00,0x00,0x00,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x08,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x70,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x40,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x78,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x78,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x70,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x08,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x80,0x00};
static const unsigned char PROGMEM image_paint_25_copy_1_bits[] = {0xf0,0x00,0x7e,0x00,0x1f,0xe0,0x03,0xf8,0x00,0x38};
static const unsigned char PROGMEM image_paint_26_bits[] = {0x80};
static const unsigned char PROGMEM image_paint_28_1_bits[] = {0x40,0x00,0x80};
static const unsigned char PROGMEM image_paint_28_bits[] = {0x00,0x20,0x01,0xfc,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x81,0x00,0x9d,0x01,0xfe,0x01,0xfe,0x03,0xfc,0x03,0xfc,0x07,0xf8,0x07,0xf8,0x0f,0xf0,0x01,0x60,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0f,0xf0,0xff,0xf0,0x0f,0xf8,0x07,0xf8,0x7f,0xfc,0x03,0xfc,0x01,0xfe,0x01,0xfe,0x00,0x81,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0xfe,0x00,0x10};
static const unsigned char PROGMEM image_paint_29_bits[] = {0xf1};
static const unsigned char PROGMEM image_paint_30_bits[] = {0x10,0x00,0x00,0x00,0x00,0xfe,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x40,0x00,0x00,0x00,0x01,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x7f,0x00,0x00,0x00,0x00,0x08,0x00,0x00,
0x00,0x00};
static const unsigned char PROGMEM image_paint_33_bits[] = {0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x80};
static const unsigned char PROGMEM image_paint_5_bits[] = {0xf8,0xc0,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x80,0xc0,0xf8};

int playerHand[6], dealerHand[6];
int pCount = 0, dCount = 0;
int selectedOption = 0;
bool gameOver = false;
String statusMsg = "";

const unsigned long PADDLE_RATE = 64;
const unsigned long BALL_RATE = 16;
const uint8_t PADDLE_HEIGHT = 12;
const uint8_t SCORE_LIMIT = 9;
bool game_over, win;
uint8_t player_score, mcu_score;
uint8_t ball_x = 53, ball_y = 26;
uint8_t ball_dir_x = 1, ball_dir_y = 1;
unsigned long ball_update;
unsigned long paddle_update;
const uint8_t MCU_X = 12;
uint8_t mcu_y = 16;
const uint8_t PLAYER_X = 115;
uint8_t player_y = 16;

int playerX = 10;
int playerY = 35;
int lives = 3;
long score2 = 0;
unsigned long lastShotTime = 0;
bool nextShotLeft = true;

bool bossActive = false;
int bossHP = 100;
int bossY = 32;
bool bossDirDown = true;
long nextBossAt = 1000;
unsigned long lastBossShotTime = 0;

#define MAX_STARS 10
struct Star { float x; int y; float speed; };
Star stars[MAX_STARS];

#define MAX_BULLETS 6
struct Bullet { bool active; int x; int y; };
Bullet bullets[MAX_BULLETS];

#define MAX_BOSS_BULLETS 4
struct BossBullet { bool active; float x; int y; };
BossBullet bossBullets[MAX_BOSS_BULLETS];

#define MAX_ENEMIES 5
struct Enemy { bool active; float x; int y; int type; float speed; int rot; int hp; };
Enemy enemies[MAX_ENEMIES];

bool gameOver2 = false;
int difficulty = 1;

enum MenuState {
  MAIN_MENU, IR_MENU, IR_SAVED_MENU, IR_UNIVERSAL_MENU, 
  GAMES_MENU, BLUE_MENU, SPAM_MENU, SETTINGS_MENU, WLAN_MENU, 
  TV_REMOTE_UI, AC_REMOTE_UI,
  Audio_REMOTE_UI, Epson_REMOTE_UI,
  WLAN_SCANNING, DEAUTH_SCANNING,
  WLAN_SCAN_LIST, WLAN_PASSWORD_ENTRY, WLAN_CONNECTING, WLAN_STATUS,
  WLAN_TOOLS_MENU, DEAUTH_LIST, DEAUTH_CLIENTS, SNIFFER_UI, LINKBYPASS_UI,
  BLE_SCAN, BLE_DEVICE_DETAIL, BLE_SNIFFER_UI, ABOUT_UI,
  EVIL_TWIN_SELECT, EVIL_TWIN_UI
};
MenuState currentState = MAIN_MENU;

static const unsigned char PROGMEM image__CHANNEL_UP_bits[] = {0xff,0xff,0xf8,0xc0,0x00,0x18,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x20,0x08,0x80,0x60,0x08,0x80,0xe0,0x08,0x80,0x60,0x08,0x80,0x20,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0xc0,0x00,0x18,0xff,0xff,0xf8};
static const unsigned char PROGMEM image_CHANNEL_DOWN_bits[] = {0xff,0xff,0xf8,0xc0,0x00,0x18,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x20,0x08,0x80,0x30,0x08,0x80,0x38,0x08,0x80,0x30,0x08,0x80,0x20,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0xc0,0x00,0x18,0xff,0xff,0xf8};
static const unsigned char PROGMEM image_MENU_BUTTON_bits[] = {0xff,0xff,0xe0,0xc0,0x00,0x60,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0xc0,0x00,0x60,0xff,0xff,0xe0};
static const unsigned char PROGMEM image_POWER_BUTTON_bits[] = {0xff,0xff,0xe0,0xc0,0x00,0x60,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x81,0xf0,0x20,0x82,0x08,0x20,0x84,0x04,0x20,0x88,0x02,0x20,0x90,0x01,0x20,0x90,0x01,0x20,0xbf,0x01,0x20,0x90,0x01,0x20,0x90,0x01,0x20,0x88,0x02,0x20,0x84,0x04,0x20,0x82,0x08,0x20,0x81,0xf0,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0xc0,0x00,0x60,0xff,0xff,0xe0};
static const unsigned char PROGMEM image_TV_s_TEXT_bits[] = {0x24,0x2a,0x2a,0x2a,0x12,0x00,0x00,0xc0,0xe0,0x10,0x00,0x00,0xf8,0x04,0x02,0x04,0xf8,0x00,0xc0,0x80,0xfe,0x80,0xc0};
static const unsigned char PROGMEM image_VOL_DOWN_bits[] = {0xff,0xff,0xf0,0xc0,0x00,0x30,0x80,0x00,0x10,0x80,0x00,0x10,0x80,0x00,0x10,0x80,0x00,0x10,0x80,0x60,0x10,0x80,0x00,0x10,0x81,0xf8,0x10,0x80,0xf0,0x10,0x80,0x60,0x10,0x80,0x60,0x10,0x80,0x00,0x10,0x80,0x00,0x10,0x80,0x00,0x10,0x80,0x00,0x10,0x80,0x00,0x10,0xc0,0x00,0x30,0xff,0xff,0xf0};
static const unsigned char PROGMEM image_VOL_UP_bits[] = {0xff,0xff,0xf0,0xc0,0x00,0x30,0x80,0x00,0x10,0x80,0x00,0x10,0x80,0x00,0x10,0x80,0xf0,0x10,0x81,0x08,0x10,0x80,0x60,0x10,0x80,0x00,0x10,0x81,0xf8,0x10,0x80,0xf0,0x10,0x80,0x60,0x10,0x80,0x60,0x10,0x80,0x00,0x10,0x80,0x00,0x10,0x80,0x00,0x10,0x80,0x00,0x10,0xc0,0x00,0x30,0xff,0xff,0xf0};

static const unsigned char PROGMEM image_paint_11_bits[] = {0x80};
static const unsigned char PROGMEM image_paint_12_bits[] = {0x80,0x00,0x80};
static const unsigned char PROGMEM image_paint_23_bits[] = {0x24,0x2a,0x2a,0x2a,0x12,0x00,0x00,0xc0,0xe0,0x10,0x00,0x00,0x44,0x82,0x82,0x82,0x7c,0x00,0x3e,0x48,0x88,0x48,0x3e};
static const unsigned char PROGMEM image_paint_25_bits[] = {0xff,0xff,0xe0,0xc0,0x00,0x60,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x80,0x20,0x80,0xc0,0x20,0x80,0xe0,0x20,0x80,0xf0,0x20,0x80,0xe0,0x20,0x80,0xc0,0x20,0x80,0x80,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0xc0,0x00,0x60,0xff,0xff,0xe0};
static const unsigned char PROGMEM image_paint_51_bits[] = {0xff,0xff,0xe0,0xc0,0x00,0x60,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x81,0xf0,0x20,0x82,0x08,0x20,0x84,0x04,0x20,0x88,0x02,0x20,0x90,0x01,0x20,0x90,0x01,0x20,0xbf,0x01,0x20,0x90,0x01,0x20,0x90,0x01,0x20,0x88,0x02,0x20,0x84,0x04,0x20,0x82,0x08,0x20,0x81,0xf0,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0xc0,0x00,0x60,0xff,0xff,0xe0};
static const unsigned char PROGMEM image_paint_67_1_bits[] = {0xff,0xff,0xe0,0xc0,0x00,0x60,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x81,0xf0,0x20,0x80,0xe0,0x20,0x80,0x40,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0xc0,0x00,0x60,0xff,0xff,0xe0};
static const unsigned char PROGMEM image_paint_67_copy_1_bits[] = {0xff,0xff,0xe0,0xc0,0x00,0x60,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x40,0x20,0x80,0xe0,0x20,0x81,0xf0,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0xc0,0x00,0x60,0xff,0xff,0xe0};

static const unsigned char PROGMEM image_paint_1_bits[] = {0x80};
static const unsigned char PROGMEM image_paint_14_bits[] = {0xff,0xff,0xf8,0xc0,0x00,0x18,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x20,0x08,0x80,0x30,0x08,0x80,0x38,0x08,0x80,0x30,0x08,0x80,0x20,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0xc0,0x00,0x18,0xff,0xff,0xf8};
static const unsigned char PROGMEM image_paint_13_bits[] = {0xff,0xff,0xf0,0xc0,0x00,0x30,0x80,0x00,0x10,0x80,0x00,0x10,0x80,0x00,0x10,0x80,0xf0,0x10,0x81,0x08,0x10,0x80,0x60,0x10,0x80,0x00,0x10,0x81,0xf8,0x10,0x80,0xf0,0x10,0x80,0x60,0x10,0x80,0x60,0x10,0x80,0x00,0x10,0x80,0x00,0x10,0x80,0x00,0x10,0x80,0x00,0x10,0xc0,0x00,0x30,0xff,0xff,0xf0};
static const unsigned char PROGMEM image_paint_15_bits[] = {0xff,0xff,0xf0,0xc0,0x00,0x30,0x80,0x00,0x10,0x80,0x00,0x10,0x80,0x00,0x10,0x80,0x00,0x10,0x80,0x60,0x10,0x80,0x00,0x10,0x81,0xf8,0x10,0x80,0xf0,0x10,0x80,0x60,0x10,0x80,0x60,0x10,0x80,0x00,0x10,0x80,0x00,0x10,0x80,0x00,0x10,0x80,0x00,0x10,0x80,0x00,0x10,0xc0,0x00,0x30,0xff,0xff,0xf0};
static const unsigned char PROGMEM image_paint_18_bits[] = {0xff,0xff,0xf8,0xc0,0x00,0x18,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x20,0x08,0x80,0x60,0x08,0x80,0xe0,0x08,0x80,0x60,0x08,0x80,0x20,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0x80,0x00,0x08,0xc0,0x00,0x18,0xff,0xff,0xf8};
static const unsigned char PROGMEM image_paint_27_bits[] = {0x80,0x00,0x80};
static const unsigned char PROGMEM image_paint_22_bits[] = {0xff,0xff,0xe0,0xc0,0x00,0x60,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x81,0xf0,0x20,0x82,0x08,0x20,0x84,0x04,0x20,0x88,0x02,0x20,0x90,0x01,0x20,0x90,0x01,0x20,0xbf,0x01,0x20,0x90,0x01,0x20,0x90,0x01,0x20,0x88,0x02,0x20,0x84,0x04,0x20,0x82,0x08,0x20,0x81,0xf0,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0xc0,0x00,0x60,0xff,0xff,0xe0};
static const unsigned char PROGMEM image_paint_32_bits[] = {0xff,0xff,0xe0,0xc0,0x00,0x60,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0xc0,0x00,0x60,0xff,0xff,0xe0};
static const unsigned char PROGMEM image_paint_0_bits[] = {0x1c,0x22,0x22,0x22,0x1c,0x00,0x00,0x02,0xbe,0x22,0x00,0x00,0xfe,0x14,0x22,0x22,0x1c,0x00,0x3e,0x04,0x02,0x02,0x3c,0x00,0x3e,0x48,0x88,0x48,0x3e};

static const unsigned char PROGMEM image_OFF_Text_bits[] = {0x80,0xc0,0xe0,0x00,0x80,0xc0,0xe0,0x00,0xe0,0xa0,0xe0};
static const unsigned char PROGMEM image_ON_Text_bits[] = {0xe0,0x80,0xe0,0x00,0xe0,0xa0,0xe0};
static const unsigned char PROGMEM image_paint_101_bits[] = {0x80};
static const unsigned char PROGMEM image_paint_102_bits[] = {0x80,0x00,0x80};
static const unsigned char PROGMEM image_paint_121_bits[] = {0xff,0xff,0xe0,0xc0,0x00,0x60,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x82,
  0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x82,0x48,0x20,0x80,0x00,
  0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0xc0,0x00,0x60,0xff,0xff,0xe0};
static const unsigned char PROGMEM image_paint_122_bits[] = {0x1e,0x20,0x20,0x10,0x3e,0x00,0x1c,0x22,0x22,0x22,0x1c,0x00,0x24,0x2a,0x2a,0x2a,0x12,0x00,0x18,0x24,0x24,0x18,
  0x3f,0x00,0x82,0x92,0x92,0x92,0xfe};
static const unsigned char PROGMEM image_Richtige_ON_button_bits[] = {0xff,0xff,0xe0,0xc0,0x00,0x60,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x81,0xf0,
  0x20,0x82,0x08,0x20,0x84,0x04,0x20,0x88,0x02,0x20,0x90,0x01,0x20,0x90,0x01,0x20,0xbf,0x01,0x20,0x90,0x01,0x20,0x90,0x01,0x20,0x88,0x02,0x20,0x84,0x04,0x20,0x82,0x08,0x20,
  0x81,0xf0,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0x80,0x00,0x20,0xc0,0x00,0x60,0xff,0xff,0xe0};

void switchMenu(MenuState newState);
void drawMenu();

String classifyBleDevice(uint16_t appearance, String name, String advUuids) {
  String n = name; n.toLowerCase();
  String u = advUuids; u.toLowerCase();

  switch (appearance) {
    case 0x00C0: return "Maus";
    case 0x00C1: return "Trackball";
    case 0x00C2: return "Tastatur";
    case 0x0180: return "Medienplayer";
    case 0x0182: return "Musikbox";
    case 0x0183: return "Musikbox";
    case 0x0280: return "Fitness-Tracker";
    case 0x0281: return "Smartwatch";
    case 0x0340: return "Lautsprecher";
    case 0x0341: return "Mikrofon";
    case 0x03C0: return "Drucker";
    case 0x03C1: return "Scanner";
    case 0x0400: return "Kamera";
    case 0x0540: return "Smartwatch";
    case 0x0A00: return "PC";
    case 0x0A01: return "PC";
    case 0x0A02: return "PC";
    case 0x0A04: return "Server";
    case 0x0A05: return "Tragbarer PC";
    case 0x0F00: return "Smartphone";
    case 0x0080: return "Smartphone";
  }

  if (u.indexOf("180f") >= 0 || u.indexOf("180d") >= 0 || u.indexOf("180c") >= 0)
    return "Fitness/Wearable";
  if (u.indexOf("1812") >= 0) return "Tastatur/Maus";
  if (u.indexOf("180a") >= 0 && u.indexOf("1800") >= 0) return "Handy/PC";
  if (u.indexOf("110b") >= 0 || u.indexOf("110a") >= 0 || u.indexOf("110e") >= 0)
    return "Musikbox";
  if (u.indexOf("1802") >= 0 || u.indexOf("1803") >= 0) return "Unbekannt";

  if (n.indexOf("iphone") >= 0 || n.indexOf("android") >= 0 || n.indexOf("galaxy") >= 0 ||
      n.indexOf("pixel") >= 0 || n.indexOf("samsung") >= 0 || n.indexOf("xiaomi") >= 0 ||
      n.indexOf("huawei") >= 0 || n.indexOf("oneplus") >= 0 || n.indexOf("oppo") >= 0)
    return "Handy";
  if (n.indexOf("win") >= 0 || n.indexOf("pc") >= 0 || n.indexOf("laptop") >= 0 ||
      n.indexOf("thinkpad") >= 0 || n.indexOf("notebook") >= 0 || n.indexOf("mac") >= 0)
    return "PC";
  if (n.indexOf("speaker") >= 0 || n.indexOf("box") >= 0 || n.indexOf("jbl") >= 0 ||
      n.indexOf("sonos") >= 0 || n.indexOf("bose") >= 0 || n.indexOf("sound") >= 0)
    return "Musikbox";
  if (n.indexOf("head") >= 0 || n.indexOf("buds") >= 0 || n.indexOf("airpod") >= 0 ||
      n.indexOf("ear") >= 0) return "Kopfhörer";
  if (n.indexOf("mic") >= 0) return "Mikrofon";
  if (n.indexOf("mouse") >= 0 || n.indexOf("maus") >= 0) return "Maus";
  if (n.indexOf("key") >= 0 || n.indexOf("keyboard") >= 0) return "Tastatur";
  if (n.indexOf("watch") >= 0 || n.indexOf("band") >= 0 || n.indexOf("mi band") >= 0)
    return "Smartwatch";
  if (n.indexOf("tv") >= 0) return "TV";
  if (n.indexOf("printer") >= 0 || n.indexOf("drucker") >= 0) return "Drucker";

  return "Unbekannt";
}

void drawWlanPasswordEntry() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setCursor(0, 0);
  display.println(connectSSID.length() > 21 ? connectSSID.substring(0, 21) : connectSSID);
  display.drawLine(0, 9, 128, 9, SSD1306_WHITE);

  display.setCursor(0, 14);
  display.print("Pass: ");
  int shown = min((int)connectPassword.length(), 18);
  for (int i = 0; i < shown; i++) display.print("*");

  display.drawLine(0, 26, 128, 26, SSD1306_WHITE);
  display.setTextSize(3);
  display.setCursor(4, 34);
  char c = wlanCharset[wlanCharIndex];
  display.print(c == ' ' ? "[_]" : String(c));

  display.setTextSize(1);
  display.setCursor(0, 56);
  display.print("Re=uebern. Su=verbinden");
  display.display();
}

void drawWlanConnecting() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setCursor(0, 24);
  display.println("Verbinde...");
  display.setCursor(0, 36);
  display.println(connectSSID);
  display.display();
}

void drawScanningUI() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setCursor(0, 24);
  display.println("Scanning...");
  display.setCursor(0, 36);
  display.println("Bitte warten...");
  display.display();
}

void drawWlanStatus() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setCursor(0, 0);
  if (WiFi.status() == WL_CONNECTED) {
    display.println("Verbunden:");
    display.println(WiFi.SSID());
    display.println(WiFi.localIP().toString());
  } else {
    display.println("Nicht verbunden");
  }
  if (wlanLastError.length() > 0) display.println(wlanLastError);
  display.setCursor(0, 54);
  display.print("Submit = zurueck");
  display.display();
}

void showScannedNetworks() {
  int n = WiFi.scanComplete();
  int count = min(n, MAX_WLAN_RESULTS - 1);

  if (count == 0) {
    wlanLastError = "Nichts gefunden!";
    switchMenu(WLAN_STATUS);
    drawMenu();
    return;
  }

  for (int i = 0; i < count; i++) {
    String name = WiFi.SSID(i);
    if (name.length() == 0) name = "(versteckt)";
    wlanOpen[i] = (WiFi.encryptionType(i) == WIFI_AUTH_OPEN);
    bool locked = !wlanOpen[i];
    wlanScanMenu[i] = name + (locked ? " *" : "");
  }
  wlanScanMenu[count] = "< Back";
  wlanScanCount = count + 1;
  switchMenu(WLAN_SCAN_LIST);
  drawMenu();
}

void connectToWifi() {
  WiFi.mode(WIFI_STA);
  WiFi.begin(connectSSID.c_str(), connectPassword.c_str());
  wlanConnectStart = millis();
  switchMenu(WLAN_CONNECTING);
  drawMenu();
}

const int MAIN_ITEMS = 5;
String mainMenu[MAIN_ITEMS] = {"Infrared", "Games", "Bluetooth", "WLAN", "Settings"};
const int SETTINGS_ITEMS = 7;
String settingsMenu[SETTINGS_ITEMS] = {"Brightness", "UTC", "WLAN", "BUZZER-VOL", "Hard-Reset", "About", "< Back"};
const int WLAN_ITEMS = 3;
String wlanMenu[WLAN_ITEMS] = {"Scanning", "Status", "< Back"};
const int IR_ITEMS = 3;
String irMenu[IR_ITEMS] = {"Saved", "Universell", "< Back"};
const int Blue_ITEMS = 4;
String BlueMenu[Blue_ITEMS] = {"Spam", "Scan", "Sniffer", "< Back"};
const int SPAM_ITEMS = 6;
String spamMenu[SPAM_ITEMS] = {"BLE-Jammer", "Samsung Spam", "Airpods Spam", "Apple Spam", "Windows Spam", "< Back"};
const int WLAN_TOOLS_ITEMS = 5;
String wlanToolsMenu[WLAN_TOOLS_ITEMS] = {"Deauther", "Sniffer", "Evil Twin", "LinkBypass", "< Back"};
const int SAVED_ITEMS = 6;
String savedMenu[SAVED_ITEMS] = {"TV Wohnzimmer", "DVD Player", "Receiver", "Sophie Fernsehr", "LED", "< Back"};
const int UNIV_ITEMS = 11;
String univMenu[UNIV_ITEMS] = {"TV's", "AC", "Audio", "Cameras", "Epson", "Projectors", "Consolen", "LED'S", "Soundbars", "Streamingde...", "< Back"};
const int GAMES_ITEMS = 5;
String gamesMenu[GAMES_ITEMS] = {"Ping Pong", "BlackJack", "Space Glider", "Doodle Jump", "< Back"};

int selectedIndex = 0;
int scrollOffset = 0;
const int ITEMS_PER_PAGE = 4;

String bleScanMenu[MAX_BLE_RESULTS + 1];
int bleScanCount = 0;
bool bleScanning = false;
bool bleInitialized = false;

BLEDeviceInfo bleDevices[MAX_BLE_RESULTS];
int bleDetailDevice = 0;
int bleDetailLine = 0;

String bleBytesToHex(const std::string &data) {
  String out = "";
  char buf[4];
  for (size_t i = 0; i < data.length() && i < 16; i++) {
    snprintf(buf, sizeof(buf), "%02X ", (uint8_t)data[i]);
    out += buf;
  }
  if (data.length() > 16) out += "...";
  return out;
}

#define MAX_SNIFFER_UNIQUE 20
uint8_t snifferSeen[MAX_SNIFFER_UNIQUE][6];
int snifferSeenCount = 0;

bool bleSnifferRunning = false;
unsigned long blePktCount = 0;
unsigned long blePktLastSecond = 0;
int blePktRate = 0;
int bleSnifferUnique = 0;

uint8_t bleDeviceAddr[MAX_BLE_RESULTS][6];

class BleScanCallbacks : public BLEAdvertisedDeviceCallbacks {
  void onResult(BLEAdvertisedDevice advertisedDevice) override {
    if (bleSnifferRunning) {
      blePktCount++;
      static unsigned long lastMs = 0;
      static unsigned long lastCount = 0;
      if (millis() - lastMs >= 1000) {
        blePktRate = blePktCount - lastCount;
        lastCount = blePktCount;
        lastMs = millis();
      }
      uint8_t a[6];
      memcpy(a, advertisedDevice.getAddress().getNative(), 6);
      bool known = false;
      for (int i = 0; i < snifferSeenCount; i++)
        if (memcmp(snifferSeen[i], a, 6) == 0) { known = true; break; }
      if (!known && snifferSeenCount < MAX_SNIFFER_UNIQUE)
        memcpy(snifferSeen[snifferSeenCount++], a, 6);
      bleSnifferUnique = snifferSeenCount;
      return;
    }
  }
};

static void bleScanResultCB(BLEScanResults results) {
  bleScanNeedsRestart = true;
}

void bleScanTick() {
  if (!bleScanning) return;
  if (bleScanNeedsRestart) {
    BLEDevice::getScan()->start(0, bleScanResultCB, /*is_continue=*/false);
    bleScanNeedsRestart = false;
  }
}

class MyScanCB : public BLEAdvertisedDeviceCallbacks {
  void onResult(BLEAdvertisedDevice advertisedDevice) override {
    uint8_t mac[6];
    memcpy(mac, advertisedDevice.getAddress().getNative(), 6);

    int idx = -1;
    for (int i = 0; i < bleScanCount; i++)
      if (memcmp(bleDevices[i].address, mac, 6) == 0) { idx = i; break; }
    if (idx < 0 && bleScanCount < MAX_BLE_RESULTS)
      idx = bleScanCount++;

    if (idx < 0) return;

    bool isNew = !bleDevices[idx].updated;

    memcpy(bleDevices[idx].address, advertisedDevice.getAddress().getNative(), 6);
    bleDevices[idx].addrType = advertisedDevice.getAddressType();

    String n = advertisedDevice.getName().c_str();
    if (n.length() == 0) n = advertisedDevice.toString().c_str();
    if (n.length() == 0) n = "(unbenannt)";
    String addrStr = advertisedDevice.getAddress().toString().c_str();
    if (n.indexOf(addrStr) >= 0) n = addrStr;
    bleDevices[idx].name = n;

    bleScanMenu[idx] = n;
    if (isNew) memcpy(bleDeviceAddr[idx], mac, 6);

    BLEDeviceInfo &d = bleDevices[idx];
    d.rssi = advertisedDevice.getRSSI();
    d.appearance = advertisedDevice.haveAppearance() ? advertisedDevice.getAppearance() : 0;

    d.serviceCount = 0;
    String uuidStr = "";
    if (advertisedDevice.haveServiceUUID()) {
      String u = advertisedDevice.getServiceUUID().toString().c_str();
      if (d.serviceCount < 4) { d.serviceUuids[d.serviceCount++] = u; uuidStr += u + " "; }
    }

    d.manufacturerData = "";
    if (advertisedDevice.haveManufacturerData()) {
#if ESP_ARDUINO_VERSION_MAJOR >= 3
      String md = advertisedDevice.getManufacturerData();
#else
      std::string md = advertisedDevice.getManufacturerData();
#endif
      char hx[3];
      for (size_t i = 0; i < md.length() && i < 8; i++) {
        snprintf(hx, sizeof(hx), "%02X", (uint8_t)md[i]);
        d.manufacturerData += hx;
      }
    }

    d.deviceType = classifyBleDevice(d.appearance, d.name, uuidStr);

    d.lineCount = 0;
    d.lines[d.lineCount++] = "Typ: " + d.deviceType;
    d.lines[d.lineCount++] = "Name: " + d.name;
    char mb[18];
    snprintf(mb, sizeof(mb), "%02X:%02X:%02X:%02X:%02X:%02X",
             mac[0], mac[1], mac[2], mac[3], mac[4], mac[5]);
    d.lines[d.lineCount++] = "MAC: " + String(mb);
    d.lines[d.lineCount++] = String("Addr: ") + (d.addrType ? "Random" : "Public");
    d.lines[d.lineCount++] = "RSSI: " + String(d.rssi) + " dBm";
    if (advertisedDevice.haveTXPower())
      d.lines[d.lineCount++] = "TX-Pwr: " + String(advertisedDevice.getTXPower()) + " dBm";
    for (int i = 0; i < d.serviceCount && d.lineCount < 12; i++)
      d.lines[d.lineCount++] = "SVC: " + d.serviceUuids[i];
    if (d.manufacturerData.length())
      d.lines[d.lineCount++] = "Manuf: " + d.manufacturerData;

    bleDevices[idx].updated = true;
    bleScanDirty = true;
  }
};

void startBLEScan() {
  ensureWiFiOffForBLE();
  if (!bleInitialized) { BLEDevice::init(""); bleInitialized = true; }
  bleScanCount = 0;
  selectedIndex = 0;
  scrollOffset = 0;

  BLEScan* pScan = BLEDevice::getScan();
  static MyScanCB scanCb;
  pScan->setAdvertisedDeviceCallbacks(&scanCb, true);
  pScan->setActiveScan(true);
  pScan->setInterval(45);
  pScan->setWindow(40);
  pScan->clearResults();
  bleScanNeedsRestart = false;
  bleScanning = true;
  pScan->start(0, bleScanResultCB, false);
  switchMenu(BLE_SCAN);
  drawMenu();
}

void stopBLEScan() {
  BLEScan* scan = BLEDevice::getScan();
  if (scan != nullptr) {
    scan->stop();
    scan->clearResults();
  }
  bleScanning = false;
  bleScanNeedsRestart = false;
  Serial.printf("[BLE] Scan gestoppt+clearResults, Heap=%u\n", ESP.getFreeHeap());
}

void snifferScanDoneCB(BLEScanResults results) {}

void startBLESniffer() {
  ensureWiFiOffForBLE();
  if (!bleInitialized) { BLEDevice::init(""); bleInitialized = true; }
  snifferSeenCount = 0;
  bleScanCount = 0;
  blePktCount = 0;

  BLEScan *pScan = BLEDevice::getScan();
  static BleScanCallbacks sniffCb;
  pScan->setAdvertisedDeviceCallbacks(&sniffCb, true);
  pScan->setActiveScan(false);
  pScan->start(0, snifferScanDoneCB, false);
  bleSnifferRunning = true;
  switchMenu(BLE_SNIFFER_UI);
  drawMenu();
}

void stopBLESniffer() {
  if (bleSnifferRunning) {
    BLEDevice::getScan()->stop();
    bleSnifferRunning = false;
  }
}

void drawBLESniffer() {
  display.clearDisplay();
  display.setTextSize(1);
  display.setCursor(0, 0);
  display.print("BLE SNIFFER");
  if (bleSnifferRunning) display.print(" RUN");
  display.drawLine(0, 9, 128, 9, SSD1306_WHITE);
  display.setCursor(0, 18);
  display.print("Pkts:   " + String(blePktCount));
  display.setCursor(0, 30);
  display.print("Rate:   " + String(blePktRate) + " pkt/s");
  display.setCursor(0, 42);
  display.print("Devs:   " + String(bleSnifferUnique));
  display.drawLine(0, 52, 128, 52, SSD1306_WHITE);
  display.setCursor(0, 54);
  display.print("[OK]Stop");
  display.display();
}

void drawBLEScan() {
  display.clearDisplay();
  display.setTextSize(1);

  clampScroll(bleScanCount + 1);

  if (bleScanCount == 0) {
    display.setCursor(0, 24);
    display.println(bleScanning ? "Suche..." : "Nichts gefunden!");
    display.setCursor(0, 57);
    display.print("< Back");
    display.display();
    return;
  }

  for (int i = 0; i < ITEMS_PER_PAGE; i++) {
    int item = scrollOffset + i;
    if (item < bleScanCount) {
      int yPos = i * 16;
      if (item == selectedIndex) display.drawRoundRect(0, yPos, 120, 15, 3, SSD1306_WHITE);
      display.setCursor(4, yPos + 4);
      String name = bleScanMenu[item];
      if (name.length() > 19) name = name.substring(0, 19);
      display.print(name);
    }
  }
  display.display();
}

void drawBLEDetails() {
  display.clearDisplay();
  display.setTextSize(1);

  BLEDeviceInfo &dev = bleDevices[bleDetailDevice];
  display.setCursor(0, 0);
  String t = bleScanMenu[bleDetailDevice];
  if (t.length() > 21) t = t.substring(0, 21);
  display.print(t);
  display.drawLine(0, 9, 128, 9, SSD1306_WHITE);

  int visible = 4;
  int start = 0;
  if (bleDetailLine >= visible) start = bleDetailLine - visible + 1;

  for (int i = 0; i < visible; i++) {
    int line = start + i;
    if (line >= dev.lineCount) break;
    display.setCursor(2, 14 + i * 12);
    if (line == bleDetailLine) display.print(">");
    String s = dev.lines[line];
    if (s.length() > 20) s = s.substring(0, 20);
    display.print(s);
  }
  display.setCursor(0, 56);
  display.print("OK / <  = Back");
  display.display();
}

void drawMenu();
void exitGame();
void switchMenu(MenuState newState);
#include "EvilTwin.hpp"
